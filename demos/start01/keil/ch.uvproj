# Keil uVision project ch.uvproj, settings and files
target Demo (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ch +hex
  c flags: Optim=4 oTime=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\;..\..\..\os\kernel\include;..\..\..\os\ports\RVCT\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx\STM32F1xx;..\..\..\os\hal\include;..\..\..\os\hal\platforms\STM32;..\..\..\os\hal\platforms\STM32F1xx;..\..\..\os\hal\platforms\STM32\GPIOv1;..\..\..\os\hal\platforms\STM32\DMAv1;..\..\..\os\various;..\..\..\boards\DT_STM32_P107;..\..\..\test;..\..\..\os\ports\common\ARMCMx;..\..\..\ext\lwip-1.4.0\src\include\ipv4;..\..\..\ext\lwip-1.4.0\src\include;..\..\..\os\various\lwip_bindings;..\..\..\os\various\lwip_bindings\arch
  asm misc: --cpreproc
  asm include: ..\;..\..\..\boards\OLIMEX_STM32_P107;..\..\..\os\ports\RVCT\ARMCMx\STM32F1xx
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x1
  group board
    ../../../boards/DT_STM32_P107/: board.c board.h
  group port
    ../../../os/ports/RVCT/ARMCMx/: cstartup.s chcoreasm_v7m.s chcore.c chcore_v7m.c chcore.h chcore_v7m.h chtypes.h
    ../../../os/ports/RVCT/ARMCMx/STM32F1xx/: vectors.s
    ../../../os/ports/common/ARMCMx/: nvic.c
  group kernel
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
    ../../../os/kernel/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chfiles.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
    ../../../os/various/: evtimer.c
  group hal
    ../../../os/hal/src/: gpt.c hal.c mac.c pal.c serial.c spi.c uart.c ext.c rtc.c tm.c
    ../../../os/hal/include/: gpt.h hal.h mac.h mii.h pal.h serial.h spi.h uart.h ext.h rtc.h
  group platform
    ../../../os/hal/platforms/STM32/: serial_lld.h serial_lld.c mac_lld.c spi_lld.c
    ../../../os/hal/platforms/STM32/GPIOv1/: pal_lld.h pal_lld.c
    ../../../os/hal/platforms/STM32F1xx/: stm32f10x.h hal_lld.c hal_lld.h hal_lld_f100.h hal_lld_f103.h hal_lld_f105_f107.h stm32_rcc.h stm32_dma.c stm32_dma.h
  group test
    ../../../test/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c test.h testbmk.h testdyn.h testevt.h testheap.h testmbox.h testmsg.h testmtx.h testpools.h testqueues.h testsem.h testthd.h
  group demo
    ../: main.c fm25l16.c pcf8563.c datetime.c rtc_stm32.c
    ../web/: web.c
  group lwip
    ../../../ext/lwip-1.4.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../ext/lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../ext/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../ext/lwip-1.4.0/src/netif/: etharp.c ethernetif.c slipif.c
    ../../../os/various/lwip_bindings/: lwipthread.c
    ../../../os/various/lwip_bindings/arch/: sys_arch.c
